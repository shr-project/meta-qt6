inherit pypi setuptools3

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=7a7126e068206290f3fe9f8d6c713ea6"

SRC_URI[sha256sum] = "2de925e8d421f93bcea80d511b81accfb6a7e6b249afa4a5559557b0cf817097"

BBCLASSEXTEND = "nativesdk native"
